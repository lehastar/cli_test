# IAR project USBKey.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VB ST STM32F103VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; lib\; lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar\; lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; lib\STM32F10x_StdPeriph_Driver\inc\; lib\STM32F10x_StdPeriph_Driver\src\; lib\STM32_USB-FS-Device_Driver\; lib\pt
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBKey.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: cfg\stm32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar\; lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; lib\STM32F10x_StdPeriph_Driver\inc\; lib\STM32F10x_StdPeriph_Driver\src\; lib\aes\; lib\STM32_USB-FS-Device_Driver\; lib\
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: miplus.hex
  group (top)
    ./: core.c core.h core_defines.h crc32.c crc32.h crc8.c crc8.h eeprom.c eeprom.h eeprom_defines.h main.c main.h main_defines.h outputs.c outputs.h outputs_defines.h pins.h service.c service.h settings.h spi.c spi.h spi_defines.h systick.c systick.h systick_defines.h timer1.c timer1.h usart2.c usart2.h usart2_defines.h usb_drv.c usb_drv.h usb_drv_defines.h
  group lib/CMSIS
    lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    lib/: stm32f10x_conf.h
  group lib/pt
    lib/pt/: pt.h
  group lib/SPL
    lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    lib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h
  group lib/USB
    lib/STM32_USB-FS-Device_Driver/: hw_config.c hw_config.h stm32_it.c stm32_it.h usb_conf.h usb_core.c usb_core.h usb_def.h usb_desc.c usb_desc.h usb_endp.c usb_init.c usb_init.h usb_int.c usb_int.h usb_istr.c usb_istr.h usb_lib.h usb_mem.c usb_mem.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h usb_regs.c usb_regs.h usb_sil.c usb_sil.h usb_type.h
